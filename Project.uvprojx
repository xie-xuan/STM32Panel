# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\APP\CPCheck;.\CORE;.\USER;.\BSP\inc;.\STM32Lib\inc;.\Func\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ./APP/CPCheck/: cpcheck.c
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ./BSP/src/: pwm.c usart.c public.c sysTick.c
  group STM32Lib
    ./STM32Lib/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Func
    ./Func/src/: fifo.c task.c
